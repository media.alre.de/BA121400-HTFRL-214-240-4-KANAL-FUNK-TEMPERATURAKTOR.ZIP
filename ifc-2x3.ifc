Properties of the parts of a building model (IFC2X3)

# File
Description: Funk-Heizungsaktor zur Montage im Heizkreisverteiler, 4-Kanal, IP20, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: BA121400, Funk-Heizungsaktor zur Montage im Heizkreisverteiler, 4-Kanal, IP20
In: Raum
Description: Funkaktoren (Funk-Heizungsregler), die in Verbindung mit alre-Funk-Raumtemperatursensoren eine Einzelraum-Temperaturregelung verwirklichen. Anwendung überwiegend im Sanierungsbereich oder bei Heizungsanlagenerweiterungen. 4-Kanal Funk-Temperaturaktor zur Montage im Heizkreisverteiler. Max. 3 Stellantriebe pro Kanal direkt anschließbar / max. 11 Stellantriebe gesamt, inklusive Pumpenmodul, eine Zeitzone je Kanal möglich, Master-Slave-Betrieb, Mittelwertbildung mit bis zu 8 Messstellen. Das Oberteil kann zum Anlernen der Funksensoren in den einzelnen Räumen abgenommen werden. Voraussetzung dafür ist die Verwendung einer optionalen, handelsüblichen 9 V Batterie. Durch die Kanalauswahl- und eine Anlerntaste kann das Anlernen der Sensoren sehr einfach durchgeführt werden.; Classification: EC000436 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: BA121400; ModelLabel: HTFRL-214.240; GlobalTradeItemNumber: 4050528076847; ProductURL: https://alre.de/produkt_BA121400
Pset_Specification - NominalLength: 0.197 m; NominalWidth: 0.1 m; NominalDepth: 0.0615 m; NetWeight: 0.529
Pset_ALRE_ETIM_Properties - Montageart: Aufputz; Farbe: anthrazit; Stromversorgung: 230 V AC; Anzahl der Relais: 5; Werkstoffgüte: Thermoplast; Werkstoff: Kunststoff; Funkfrequenz: 868.3; Ausführung der Oberfläche: glänzend; Geeignet für Schutzart (IP): IP20; ETIM-Klasse: EC000436; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-BA121400.pdf
